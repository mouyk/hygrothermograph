# Keil uVision project ca51f2.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: CA51F252L3-ZigBee +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\source;.\include
  asm include: .\source;.\include
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: uart.c main.c delay.c system_clock.c lcd.c gpio.c gxhtc.c Disp.c buzzer.c adc.c rtc.c key.c time.c
  group Lib
    ./lib/: STARTUP.A51
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
